# Keil uVision project ue4.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ue4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\ModuleLCD;.\Modules
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
  group Module
    ./Modules/: Gpio.c Gpio.h Timer.c Timer.h
    ./: State_A.c State_B.c StateMachine.h StateMachine.c EventQueue.c EventQueue.h Key.c Key.h
  group ModuleLCD
    ./ModuleLCD/: Consolas.c Image.c Lcd.c Lcd.h MonochromeImage.c
  group ModuleTSC
    ./: Tsc.h Tsc.c
software components: CMSIS:CORE 6.2.0, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:Startup 1.0.0
